# Repository fengecho/electronic

File README.md:

All work in this repository is under the license bsd available [here] (https://github.com/echopen/electronic/blob/master/LICENSE)

# electronic

This repository is dedicated to the electronic part. The electronic shemas of the modules printed with kicad can be found in the kicad repository

## KiCad design kicad/Daugter_boards/DB_High_Voltage/V2/DB_HV_V2.kicad_pcb

File kicad/README.md:

This repository is dedicated to the kicad files of the modules of the ultrasound probe.

To edit a Bom, on linux, one need to install xsltproc:
sudo apt-get install xsltproc

Then when clicking on the BOM icon, select Add Plugin, the plugins can be found in:
usr/lib/kicad/plugins
to edit a csv file you have to edit the command by changing "%O" to "%O.csv": 
xsltproc -o "%O" "/usr/lib/kicad/plugins/bom2csv.xsl" "%I"
become:
xsltproc -o "%O.csv" "/usr/lib/kicad/plugins/bom2csv.xsl" "%I"

to improve the BOM output one can for example use the tool in http://www.hashdefineelectronics.com/kicad-bom-wizard/

To add a librairy with a relative path go to Preferences/Component librairies then in User defined search path add the folder you want to add and select use relative path. In Component library files add the librairy, by doing this, the library is added with an absolute path, to access a relative path edit the .rpo filewith a text editor, at the end of the file you will find the librairy you added with the absolute path, clear all the path and keep only the name of the labrairy.

When you to make a PCB for the first time, go to your Eschema file and click on the CvPcb icon. In the new window, click on the Preferences menu and select Footprint Librairies. In the new window delete all the librairies that are listed (there is not the librairies install on the computer and you will have error when you will want to associate footprint) then click on Append with wizard. Now you use the online librairies. Now you can associate the footprints with the component, enjoy.

Some interesting tutorial about kicad can be found on: https://www.wayneandlayne.com/blog/category/kicad-tutorials/

Board: 2 copper layers, 40.6 x 50.8 mm, 6 parts (0 on the bottom side), 5 nets.

Parts:
P1, P3: CONN_01X19; Socket_Strip_Straight_1x19
P2: CONN_01X02; Socket_Strip_Angled_1x02
P4: SMA
RV1: POT; Potentiometer_Bourns_3296Y_3-8Zoll_Angular_ScrewUp
U1: R05-100B; RECOM

Connections:
GND: P1.1, P2.2, P3.1, P4.2, U1.2, U1.3, U1.12, U1.13
unnamed: P2.1, P4.1, RV1.3, U1.10, U1.15
unnamed: P3.2, U1.22, U1.23
unnamed: RV1.1, U1.9, U1.16
unnamed: RV1.2, U1.8, U1.17

## KiCad design kicad/Daugter_boards/DB_Filter/V1/DB_Filter_V1.kicad_pcb

Parts:
C1: 1000p
L1: 10u
P1, P2: CONN_01X19
R1: 330

Connections:
GND: P1.1, P2.1, R1.2
unnamed: C1.1, L1.2
unnamed: C1.2, P1.3
unnamed: L1.1, P2.4, R1.1

Board: 2 copper layers, 20.3 x 50.8 mm, 5 parts (0 on the bottom side), 4 nets.

## KiCad design kicad/Daugter_boards/DB_High_Voltage/V1/DB_HV_V1.kicad_pcb

Parts:
C1: 10n; C_Disc_D6_P5
C2: 47n; C_Disc_D6_P5
C3: 47u; CP36V
C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14: 4.7u; CP36V
D1, D12: 4001; Diode_DO-35_SOD27_Horizontal_RM10
D2, D3, D4, D5, D6, D7, D8, D9, D10, D11: 1N5062; Diode_DO-35_SOD27_Horizontal_RM10
P1, P3: CONN_01X19; Socket_Strip_Straight_1x19
P2: CONN_01X02; Socket_Strip_Straight_1x02
P4: SMA; bnc
Q1, Q2: 2N2222; OldSowjetaera_Transistor_Type-II_BigPads
Q3: 2N2907; OldSowjetaera_Transistor_Type-II_BigPads
R1: 2.2k; Resistor_Horizontal_RM7mm
R2: 12k; Resistor_Horizontal_RM7mm
R3: 3.3k; Resistor_Horizontal_RM7mm
R4: 1.8k; Resistor_Horizontal_RM7mm
U1: LM555N; RV_Disc_D12_W7.1_P7.5

Connections:
GND: C1.1, C2.1, C4.1, C14.1, D1.1 (K), P1.1, P2.2, P3.1, P4.2 (Ext), Q1.1, Q3.3, U1.1 (GND)
unnamed: C1.2, U1.5 (CV)
unnamed: C2.2, R2.2, U1.2 (TR), U1.6 (THR)
unnamed: C3.1, Q2.1, Q3.1
unnamed: C3.2, C5.1, D1.2 (A), D2.1 (K)
unnamed: C4.2, C6.1, D2.2 (A), D3.1 (K)
unnamed: C5.2, C7.1, D3.2 (A), D4.1 (K)
unnamed: C6.2, C8.1, D4.2 (A), D5.1 (K)
unnamed: C7.2, C9.1, D5.2 (A), D6.1 (K)
unnamed: C8.2, C10.1, D6.2 (A), D7.1 (K)
unnamed: C10.2, C12.1, D8.2 (A), D9.1 (K)
unnamed: C9.2, C11.1, D7.2 (A), D8.1 (K)
unnamed: C11.2, C13.1, D9.2 (A), D10.1 (K)
unnamed: C12.2, D10.2 (A), D11.1 (K)
unnamed: C13.2, D11.2 (A), D12.1 (K)
unnamed: C14.2, D12.2 (A), P2.1, P4.1 (In)
unnamed: P1.12, Q2.3, R4.1
unnamed: Q1.2, R3.1
unnamed: Q1.3, Q2.2, Q3.2, R4.2
unnamed: R1.1, R2.1, U1.7 (DIS)
unnamed: R3.2, U1.3 (Q)
VCC: P1.2, R1.2, U1.4 (R), U1.8 (VCC)

Board: 2 copper layers, 57.2 x 50.8 mm, 38 parts (0 on the bottom side), 22 nets.

## KiCad design kicad/Daugter_boards/DB_Envelope_detector/V2/DB_Envelope_detector_V2.kicad_pcb

Board: 2 copper layers, 30.5 x 50.8 mm, 12 parts (0 on the bottom side), 8 nets.

Parts:
C1: 10nF; C_Disc_D6_P5
C2: 1nF; C_Disc_D6_P5
C3: 33nF; C_Disc_D6_P5
P1, P2: CONN_01X19; Socket_Strip_Straight_1x19
Q1: 2N2222; TO-18_3Pin
Q2, Q3: 2N2907; TO-18_3Pin
R1: 2800; Resistor_Horizontal_RM10mm
R2: 1000; Resistor_Horizontal_RM10mm
R3, R4: 330; Resistor_Horizontal_RM10mm

Connections:
GND: P1.1, P2.1, R2.2
unnamed: C1.1, Q1.2, R1.2, R2.1
unnamed: C1.2, P1.4
unnamed: C2.1, C3.2, P2.5, Q2.2, Q3.3, R4.1
unnamed: C2.2, Q1.3, Q3.2, R3.2
unnamed: C3.1, P2.18, Q2.3, R4.2
unnamed: P2.2, Q3.1, R1.1, R3.1
unnamed: Q1.1, Q2.1

## KiCad design kicad/Daugter_boards/DB_Envelope_detector/V1/DB_Envelope_detector_V1.kicad_pcb

Board: 2 copper layers, 34.3 x 53.3 mm, 5 parts (2 on the bottom side), 3 nets.

Parts:
C1: 10p; C_Disc_D3_P2.5
D1: 1N60; Diode_DO-35_SOD27_Horizontal_RM10
P1, P2: CONN_01X19; Pin_Header_Straight_1x19
R1: 3.9k; Resistor_Horizontal_RM10mm

Connections:
GND: C1.2, P1.1, P2.1, R1.2
unnamed: C1.1, D1.1, P2.5, R1.1
unnamed: D1.2, P1.4

## KiCad design kicad/Daugter_boards/DB_Pulser/V1/DB_Pulser_V1.kicad_pcb

Board: 2 copper layers, 43.2 x 50.8 mm, 28 parts (1 on the bottom side), 13 nets.

Parts:
C1: 100p; C_Disc_D3_P2.5
C2, C4: 100n; C_Disc_D3_P2.5
C3: 33u; C_Radial_D10_L13_P5
C5: 220p; C_Disc_D3_P2.5
D1: BAT48 0.6V; Diode_DO-35_SOD27_Horizontal_RM10
D2, D5: BZD23-18; Diode_DO-35_SOD27_Horizontal_RM10
D3: D1N4148; Diode_DO-35_SOD27_Horizontal_RM10
P1, P3: CONN_01X19; Socket_Strip_Straight_1x19
P2, P4: CONN_01X02; Socket_Strip_Angled_1x02
P5: SMA
Q1, Q3, Q5: Q2N2222; TO-18_3Pin
Q2, Q4, Q6: Q2N2907; TO-18_3Pin
Q7: IRF9610; TO-220_Neutral123_Vertical
Q8: IRF610; TO-220_Neutral123_Vertical
R1: 1k; Resistor_Horizontal_RM10mm
R2: 22; Resistor_Horizontal_RM10mm
R3, R5: 1M; Resistor_Horizontal_RM10mm
R6: 100k; Resistor_Horizontal_RM10mm
U1: SMA

Connections:
GND: C3.1, P1.1, P2.2, P3.1, P4.2, P5.2, Q1.1, Q4.3, Q6.3, U1.2
unnamed: C1.1, D1.2, Q1.2, R2.1
unnamed: C1.2, C5.1, P1.9, R2.2
unnamed: C2.1, D2.1, Q8.1, R3.1
unnamed: C2.2, C4.2, Q5.1, Q6.1
unnamed: C3.2, D2.2, P2.1, Q8.3, R3.2, U1.1
unnamed: C4.1, D5.2, Q7.1, R5.2
unnamed: C5.2, D3.2, Q2.2, R6.1
unnamed: D1.1, Q1.3, Q2.3, Q3.2, Q4.2, R1.2
unnamed: D3.1, P1.6, Q2.1, Q3.3, Q5.3, R1.1, R6.2
unnamed: D5.1, Q7.3, R5.1
unnamed: P4.1, P5.1, Q7.2, Q8.2
unnamed: Q3.1, Q4.1, Q5.2, Q6.2

## Commit log

2016-06-20 adding license file
2016-06-20 adding license file 2
2016-06-20 adding the kicad repository
2016-06-20 add_ramp_generator_schematic
2016-06-21 Ajout du schematic sur kicad du symetric supply
2016-06-27 Ajout kicad envelope detector
2016-07-06 Schematic in controlling the stepper motor
2016-07-08 add the schematic of ramp generator with FPGA & the librairy echopen including the schematic of FPGA_pluto and OPA625
2016-07-11 modification de la librairie kicad et ajout schematic avec flash board
2016-07-20 add schematic of the fpga and the dac module
2016-07-21 add schematic of the new ramp signal generate with the fpga pluto
2016-08-03 changing repository hierarchy
2016-08-03 creating MDL_Supply
2016-08-03 adding MDL_HVC
2016-08-04 adding MDL_HVC_V2
2016-08-04 adding MLD_Pulser_V2
2016-08-05 adding MDL_Pulser
2016-08-05 adding MDL_TR_swithc
2016-08-05 adding MDL_TGC
2016-08-05 adding MDL_Filter and MDL_Envelope detector
2016-08-05 adding MDL_Motor_Control
2016-08-05 update MDL_Ramp
2016-08-08 adding DB_HV
2016-08-08 updata motor repository for cloning issu
2016-08-08 DB_envelope_detector_V1
2016-08-08 adding DB_Filter
2016-08-08 adding DB_TRS_TGC
2016-08-08 DB envelope detector, motor control, pulser
2016-08-08 db pulser modif
2016-08-08 update daugter boards
2016-08-08 update DB_Pulser and adding DB_RedPitaya
2016-08-09 update MDL_Pulser_V2
2016-08-09 adding software modules (flowcharts)
2016-08-10 adding module software
2016-08-10 update MDL and DB Supply
2016-08-11 adding mecanical repo
2016-08-11 adding DB_Envelope_Detector
2016-08-16 adding gerber files of DB_HV
2016-08-16 adding DB_Motor_Control
2016-08-16 adding DB_Pulser
2016-08-16 update DB_HV_V1
2016-08-17 update DB_HV, update librairy and librairy path for MDL
2016-08-17 update figures and nomenclature of MDLs
2016-08-17 update DB_Envelope_Detector with correct librairy and footprint
2016-08-17 update librairy with correct nomenclature of transistor
2016-08-17 update DB_Envelope_Detector design
2016-08-17 update echopen footprint librairy for better finish
2016-08-17 update MDLs with new librairy
2016-08-18 inverting SMA layer position and improve finish of DB_HV
2016-08-18 improve DB_Filter finish
2016-08-18 improve DB_Mother_Board finish
2016-08-18 change nomenclature of DB_Mother_Board
2016-08-18 correct non connected pin on DB_HV
2016-08-18 the source for 3DPrinting
